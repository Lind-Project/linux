## kernel/threei/Kconfig
```kconfig
config THREEI
	bool "ThreeI Subsystem Core Support."
	default y
	help
	  Enables the ThreeI core subsystem.
```
